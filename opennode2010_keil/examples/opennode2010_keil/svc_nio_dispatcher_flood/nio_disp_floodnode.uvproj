# Keil uVision project nio_disp_floodnode.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: nio_node
  c flags: Optim=1
  c include: D:\dev\openwsn\source\node\opennode2010_keil\common\openwsn\hal\opennode2010\stm32f10x\std\inc;D:\dev\openwsn\source\node\opennode2010_keil\common\openwsn\hal\opennode2010\cm3\core;..\..\..\common
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./: apl_foundation.h nio_disp_floodnode.c
  group cm3
    ../../../common/openwsn/hal/opennode2010/cm3/core/: core_cm3.c
    ../../../common/openwsn/hal/opennode2010/cm3/device/stm32f10x/: startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group stm32f10x_std
    ../../../common/openwsn/hal/opennode2010/stm32f10x/std/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hal
    ../../../common/openwsn/hal/opennode2010/: basic_rf.c hal_assert.c hal_cc2520.c hal_cc2520base.c hal_cc2520vx.c hal_cpu.c hal_debugio.c hal_foundation.c hal_led.c hal_mcu.c hal_timer.c hal_uart.c hal_digitio.c hal_interrupt.c hal_timesync.c
  group rtl
    ../../../common/openwsn/rtl/: rtl_cache.c rtl_debugio.c rtl_foundation.c rtl_frame.c rtl_ieee802frame154.c rtl_iobuf.c rtl_lightqueue.c rtl_random.c
  group svc
    ../../../common/openwsn/svc/: svc_nio_acceptor.c svc_nio_aloha.c svc_nio_flood.c svc_nodebase.c svc_nio_dispatcher.c

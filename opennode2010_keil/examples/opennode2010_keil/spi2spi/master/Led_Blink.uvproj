# Keil uVision project Led_Blink.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Led_Blink +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./library/: cortexm3_macro.s stm32f10x_vector.s
    ./: Led_Blink.c
    ./library/src/: stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_sdio.c stm32f10x_spi.c

# Keil uVision project osx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: osx_task
  c flags: Optim=2 wLevel=2
  c include: D:\dev\openwsn\source\node\opennode2010_keil\common\openwsn\hal\opennode2010\stm32f10x\std\inc;D:\dev\openwsn\source\node\opennode2010_keil\common\openwsn\hal\opennode2010\cm3\core;..\..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: osxdemo.c appsvc1.c appsvc2.c appsvc3.c
  group cm3
    ../../../common/openwsn/hal/opennode2010/cm3/core/: core_cm3.c
    ../../../common/openwsn/hal/opennode2010/cm3/device/stm32f10x/: startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group stm32f10x_std
    ../../../common/openwsn/hal/opennode2010/stm32f10x/std/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group hal
    ../../../common/openwsn/hal/opennode2010/: hal_assert.c hal_cpu.c hal_debugio.c hal_foundation.c hal_led.c hal_mcu.c hal_rtc.c hal_uart.c hal_timer.c basic_rf.c hal_cc2520.c hal_cc2520base.c hal_cc2520vx.c hal_digitio.c hal_targetboard.c hal_interrupt.c hal_timesync.c hal_random.c hal_event.c
  group rtl
    ../../../common/openwsn/rtl/: rtl_debugio.c rtl_foundation.c rtl_dispatcher.c rtl_lightqueue.c rtl_dumpframe.c rtl_frame.c rtl_ieee802frame154.c rtl_random.c rtl_iobuf.c rtl_cache.c
  group osx
    ../../../common/openwsn/osx/: osx_taskheap.c osx_taskpool.c osx_tlsche.c osx_dba.c osx_fifosche.c osx_foundation.c osx_kernel.c
  group svc
    ../../../common/openwsn/svc/: svc_nio_acceptor.c svc_nio_dispatcher.c svc_nodebase.c svc_nio_datatree.c svc_nio_csma.c

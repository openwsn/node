# Keil uVision project hal_cc2520_regread.uvproj, settings and files
target target (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: hal_cc2520_regread +hex
  c flags: Optim=1
  c define: CONFIG_TOOLCHAIN_MDK
  c include: ..\..\..\common\openwsn\hal\opennode2010\cm3\core;..\..\..\common\openwsn\hal\opennode2010\cm3\device\stm32f10x;..\..\..\common\openwsn\hal\opennode2010\stm32f10x\std\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x200000
  group main
    ./: reg_read.c
  group cm3
    ../../../common/openwsn/hal/opennode2010/cm3/core/: core_cm3.c core_cm3.h
    ../../../common/openwsn/hal/opennode2010/cm3/device/stm32f10x/: system_stm32f10x.c startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.h
  group stm32f10x_std
    ../../../common/openwsn/hal/opennode2010/stm32f10x/std/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../../common/openwsn/hal/opennode2010/stm32f10x/: note.txt
    ../../../common/openwsn/hal/opennode2010/stm32f10x/std/inc/: misc.h stm32f10x_cec.h
  group hal
    ../../../common/openwsn/hal/opennode2010/: basic_rf.c basic_rf_security.c hal_assert.c hal_cc2520.c hal_cc2520base.c hal_cc2520base.h hal_cc2520vx.c hal_cc2520vx.h hal_debugio.c hal_digitio.c hal_foundation.c hal_interrupt.c hal_key.c hal_led.c hal_mcu.c hal_spi.c hal_uart.c util.c util_buffer.c hal_targetboard.c hal_cpu.c
  group rtl
    ../../../common/openwsn/rtl/: rtl_debugio.c rtl_foundation.c rtl_frame.c rtl_ieee802frame154.c rtl_iobuf.c rtl_lightqueue.c
target SRAM (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: hal_cc2520_regread +hex
  c flags: Optim=1
  c include: ..\..\common\openwsn\hal\opennode2010\cm3\core;..\..\common\openwsn\hal\opennode2010\cm3\device\stm32f10x;..\..\common\openwsn\hal\opennode2010\stm32f10x\std\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000

# Keil uVision project rfmodem.uvproj, settings and files
target target (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rfmodem
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group hal
    ./hal/: hal_digio.c hal_assert.c hal_board.c hal_int.c hal_mcu.c hal_rf.c hal_uart.c init.c string.c util.c util_buffer.c
  group stm32
    ./hal/stm32/: stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group main
    ./: rf_modem.c
